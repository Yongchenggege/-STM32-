# Keil uVision project A.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: A +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10_MD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP;.\Public;.\FreeRTOS\FreeRTOS-Kernel;.\FreeRTOS\FreeRTOS-Kernel\include;.\FreeRTOS\FreeRTOS-Kernel\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
    ./FreeRTOS/FreeRTOS-Kernel/: FreeRTOSConfig.h
  group startup
    ./User/: startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_crc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group APP
    ./APP/: tcs34725.c timer.c usart.c crc16.c i2c.c rgb_ratio.c cct.c RTU.c
  group Public
    ./Public/: stdelay.c
  group FreeRTOS/kernel
    ./FreeRTOS/FreeRTOS-Kernel/: croutine.c event_groups.c queue.c tasks.c timers.c stream_buffer.c list.c
  group FreeRTOS/port
    ./FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ./FreeRTOS/FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c
